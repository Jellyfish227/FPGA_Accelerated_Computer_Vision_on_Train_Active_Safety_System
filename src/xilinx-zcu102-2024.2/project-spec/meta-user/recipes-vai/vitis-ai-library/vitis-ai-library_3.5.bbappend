FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-headers-and-libraries-missing.patch;patchdir=../.."

