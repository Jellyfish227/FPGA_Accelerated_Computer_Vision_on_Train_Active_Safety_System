FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-cstdint-include-and-absl-library-missing.patch;patchdir=../../.."

