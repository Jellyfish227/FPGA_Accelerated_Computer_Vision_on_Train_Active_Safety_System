FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-cstdint-include-missing-and-outside-array-bounds.patch;patchdir=../../.."
